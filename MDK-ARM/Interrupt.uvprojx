# Keil uVision project Interrupt.uvprojx, settings and files
target N32G45x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G452CCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NationKey +hex
  AfterMake: fromelf --bin --output=.\bin\NationKey.bin .\Objects\NationKey.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\NationKey.axf --output=.\bin\NationKey.dua
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,BG95,DEBUG,DEBUG_NRF,WITH_VI_DEBUG_LEVEL,WITH_TINYDTLS,LWM2M_LOG_LEVEL=10,MU_DTLS,DT_COT,HAVE_VPRINTF
  c include: ..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32g45x_std_periph_driver\inc;..\DRIVER\inc;..\USER\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS_Cellular_Interface\1.0.1\FreeRTOS-Cellular-Interface\source\logging;..\libuarte_V30\libuarte\lwm2m\qtWakaClient;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\tinydtls;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\tinydtls\aes;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\tinydtls\ecc;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\tinydtls\platform-specific;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\tinydtls\sha2;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\win_fake_include;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\win_fake_include\arpa;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\win_fake_include\netinet;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\win_fake_include\sys;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\emb_fake;..\libuarte_V30\libuarte\lwm2m\qtWakaClient\emb_fake\arpa;..\libuarte_V30\libuarte\lwm2m\ViApi;..\libuarte_V30\libuarte\lwm2m\wakaama\coap\er-coap-13;..\libuarte_V30\libuarte\lwm2m\wakaama\core;..\libuarte_V30\libuarte\lwm2m\wakaama\examples\client;..\libuarte_V30\libuarte\lwm2m\wakaama\examples\shared;..\libuarte_V30\libuarte\lwm2m\wakaama\include;..\libuarte_V30\libuarte\lwm2m\wakaama\transport\tinydtls\include\tinydtls;..\libuarte_V30\libuarte\lwm2m\wakaama\transport\udp\include\udp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20020000 size 0x4000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c
  group DRIVER
    ../DRIVER/src/: bsp_exti.c bsp_uart.c bsp_iic.c bsp_led.c bsp_rtc.c bsp_rcc.c bsp_tim.c debug.c bsp_adc.c
  group USER
    ../USER/src/: Delay.c main.c n32g45x_it.c aisc.c BG77.c OTA.c
  group DOC
    ../: readme.txt
  group FREERTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
